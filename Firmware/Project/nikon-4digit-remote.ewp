# IAR project nikon-4digit-remote.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\..\..\STM8S_StdPeriph_Lib_V2.1.0\Libraries\STM8S_StdPeriph_Driver\inc\; ..\Source
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: nikon-4digit-remote.srec
  ILINK.IlinkOutputFile: nikon-4digit-remote.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S003
  ICCSTM8.CCIncludePath2: d:\Workspace\STM8\STM8S_StdPeriph_Lib_V2.1.0\Libraries\STM8S_StdPeriph_Driver\inc\; ..\Source
  ILINK.IlinkOutputFile: I2C-LED.out
  group FWLib
    ../../../STM8S_StdPeriph_Lib_V2.1.0/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_tim1.c stm8s_tim2.c
  group Source
    ../Source/: ihm.c led.c main.c pot.c shutter.c stm8s_it.c
