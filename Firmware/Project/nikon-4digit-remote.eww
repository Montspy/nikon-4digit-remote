<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\nikon-4digit-remote.ewp</path>
  </project>
  <batchBuild/>
</workspace>


